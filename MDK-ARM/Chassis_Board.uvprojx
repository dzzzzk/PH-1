# Keil uVision project Chassis_Board.uvprojx, settings and files
target Chassis_Board (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F407IGHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.12.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: Chassis_Board +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F407xx,USE_HAL_DRIVER,STM32F407xx,ARM_MATH_CM4,__FPU_USED=1U,__FPU_PRESENT=1U,__CC_ARM,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING
  c include: ../Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../user_code/algorithm;../user_code/application;../user_code/componet/support;../user_code/componet/include;../user_code/componet/device;../user_code/bsp;../user_code/module;../user_code/protocol;../user_code/device
  asm include: ..\Inc;../Inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User
    ../Src/: main.c gpio.c freertos.c adc.c can.c crc.c dma.c i2c.c rng.c rtc.c spi.c tim.c usart.c usb_device.c usbd_conf.c usbd_desc.c usbd_cdc_if.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_ll_usb.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_ll_adc.c stm32f4xx_hal_can.c stm32f4xx_hal_crc.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_rng.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group application
    ../user_code/application/: system_config.cpp my_test_task.cpp chassis_task.cpp communicate_task.cpp detect_task.cpp INS_task.cpp calibrate_task.cpp
  group module
    ../user_code/module/: Chassis.cpp Communicate.cpp joint_motor.cpp INS.cpp
  group algorithm
    ../user_code/algorithm/: Pid.cpp First_order_filter.cpp
  group device
    ../user_code/device/: Motor.cpp Super_cap.cpp
  group protocol
    ../user_code/protocol/: Can_receive.cpp Remote_control.cpp Referee.cpp
  group support
    ../user_code/componet/support/: fifo.c user_lib.c CRC8_CRC16.c ist8310driver.c ist8310driver_middleware.c mem_mang4.c AHRS_middleware.c BMI088Middleware.c AHRS.lib arm_cortexM4lf_math.lib user_lib.cpp BMI088driver.c
  group bsp
    ../user_code/bsp/: bsp_can.c bsp_delay.c bsp_led.c bsp_rc.c bsp_usart.c bsp_imu_pwm.c bsp_i2c.c bsp_flash.c bsp_buzzer.c bsp_spi.c bsp_adc.c
software components: CMSIS:CORE 4.3.0
